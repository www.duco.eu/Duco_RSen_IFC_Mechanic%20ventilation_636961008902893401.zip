Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T01:26:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 01:26:43 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{7AE6236C-8E06-4B7A-A067-0023B5ACD60F}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 01:26:38 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 01:26:38 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 01:26:38 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: supply valve - round_duco_ducovent design, RSen_57_AIR_FB_supply valve - ducovent design_duco:supply valve - round_duco_ducovent design:201587
In: Level 1
Type - PredefinedType: GRILLE; Classification: 57.10.90.1 (Uniformat); Material: RSen_n6_PVC_white
Type - Constraints(Type) - Default Elevation: 2000 mm
Type - Dimensions(Type) - RSen_C_depth: 22 mm; RSen_C_diameter: 215 mm; RSen_C_height: 73.5 mm; RSen_C_width: 0 mm; RSen_M_c01_diameter: 125 mm; WT_V Connection depth: 52 mm
Type - Identity Data(Type) - Assembly Code: 57.10.90.1; Cost: 0; Description: duco_ducovent design_supply valve - round; Manufacturer: Duco; Model: ducovent design; RSen_C_code_article: 4210; RSen_C_code_ETIM: Transfer air grille; RSen_C_code_ETIM_URL: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; RSen_C_code_gtin: -; RSen_C_content_creator: ThorbiQ nv; RSen_C_content_date_changed: 23/03/2018; RSen_C_content_date_issue: 22/04/2016; RSen_C_content_provider: Duco; RSen_C_content_version: V1; RSen_C_description: duco_ducovent design_supply valve - round; RSen_C_model: ducovent design; RSen_C_revit_version: 2016; RSen_C_type: round; RSen_C_type_comments: supply valve; Type Comments: supply valve; Type Name: supply valve - round_duco_ducovent design; URL: http://www.duco.eu/producten/luchtafvoer/afvoerventielen/nl-be-ducoventdesign; WT_I BaseKeynote: 57.10.90.1
Type - Materials and Finishes(Type) - RSen_C_material: RSen_n6_PVC_white
Type - Mechanical - Flow(Type) - Max Flow: 0.735722 m3/s
Type - Model Properties(Type) - WT_I Color: Ral 9010_white; WT_I Installation height: min. 18 cm above the floor; WT_I Mounting on minimum: minimium 60 cm from the wall and ceiling; WT_I Sound level: <15 dB(A) at 50 m3/h
Type - Other(Type) - Category: Air Terminals; Family Name: RSen_57_AIR_FB_supply valve - ducovent design_duco; RSen_M_c01_description: c01_supply; RSen_M_c01_pressure_loss_static: 0 Pa; RSen_M_c01_radius: 62.5 mm
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: supply valve - round_duco_ducovent design
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.0611227 m2; Size: 125 mmø; Volume: 0.00266829 m3
Identity Data - Mark: 3
Mechanical - System Classification: Supply Air
Mechanical - Flow - Flow: 0 m3/s; RSen_M_flow_rate: 0 m3/s; WT_I Maximum flow rate: OK
Other - Category: Air Terminals; Family: RSen_57_AIR_FB_supply valve - ducovent design_duco: supply valve - round_duco_ducovent design; Family and Type: RSen_57_AIR_FB_supply valve - ducovent design_duco: supply valve - round_duco_ducovent design; RSen_M_c01_flow_rate: 0 m3/s; Schedule Level: Level: Level 1; Type: RSen_57_AIR_FB_supply valve - ducovent design_duco: supply valve - round_duco_ducovent design; Type Id: RSen_57_AIR_FB_supply valve - ducovent design_duco: supply valve - round_duco_ducovent design
Phasing - Phase Created: New Construction
Text - RSen_C_content_manual: http://www.witas.be/nl/duco
