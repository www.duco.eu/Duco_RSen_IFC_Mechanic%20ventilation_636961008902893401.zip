Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T01:29:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 01:29:22 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{5A04D1A4-36D3-4EDF-BDEA-FA35E915D5FF}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 01:29:20 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 01:29:20 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 01:29:20 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionControlElement: iq-unit_duco, RSen_67_EE_FB_iq-unit_duco:iq-unit_duco:200078
In: Level 1
Type - Classification: 67.10.10 (Uniformat); Material: RSen_x_rgb 000 149 150 T00 green_gen, RSen_n_plastic_black, RSen_o_glass_clear, RSen_n_plastic_grey
Type - Constraints(Type) - Default Elevation: 1200 mm
Type - Dimensions(Type) - RSen_C_height: 106 mm; RSen_C_thickness: 58.5 mm; RSen_C_width: 164 mm
Type - Electrical(Type) - RSen_E_c02_active_power: 1.7 W; RSen_E_c02_load_class: HVAC; RSen_E_c02_number_of_poles: 1; RSen_E_c02_power_factor: 1; RSen_E_c02_voltage: 220 V
Type - Identity Data(Type) - Assembly Code: 67.10.10; Description: IQ-Unit_duco; Manufacturer: Duco; Model: IQ-unit; RSen_C_code_ETIM: intelligent control element; RSen_C_code_ETIM_URL: http://prod.etim-international.com/Class/Details?classId=EC000205&classVersion=5; RSen_C_code_gtin: 5 4 2503715 030 9; RSen_C_code_product: 0000-4193; RSen_C_content_creator: ThorbiQ nv; RSen_C_content_date_changed: 23/03/2018; RSen_C_content_date_issue: 26/02/2016; RSen_C_content_provider: Duco; RSen_C_content_version: V4; RSen_C_description: IQ-Unit_duco; RSen_C_model: IQ-unit; RSen_C_revit_version: 2016; RSen_C_type_comments: IQ-unit; Type Comments: IQ-unit; Type Name: iq-unit_duco; URL: http://www.duco.eu; WT_I BaseKeynote: 67.10.10
Type - Materials and Finishes(Type) - WT_V Display_material: RSen_o_glass_clear; WT_V Knobs_material: RSen_n_plastic_grey
Type - Model Properties(Type) - WT_I Color housing: Gray/white with colour logo Duco; WT_I Communication: RF and Wired; WT_I Confirmation: DIN rail; WT_I Connections: 24VDC voeding; Duco Wired; ModBus; schakelcontact (2x); PWM IN; PWM OUT; WT_I Protocol: Z-wave; WT_I Type: IQ-unit
Type - Other(Type) - Category: Electrical Equipment; Family Name: RSen_67_EE_FB_iq-unit_duco; RSen_E_c01_description: c1_communication connector; RSen_E_c02_description: c2_elektrical connector
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.033179 m2; Volume: 0.00101696 m3
Electrical - Circuiting - Electrical Data: c2_elektrical connector 220 V/1-2 VA
Identity Data - Mark: 1
Other - Category: Electrical Equipment; Family: RSen_67_EE_FB_iq-unit_duco: iq-unit_duco; Family and Type: RSen_67_EE_FB_iq-unit_duco: iq-unit_duco; Schedule Level: Level: Level 1; Type: RSen_67_EE_FB_iq-unit_duco: iq-unit_duco; Type Id: RSen_67_EE_FB_iq-unit_duco: iq-unit_duco
Phasing - Phase Created: New Construction
Text - RSen_C_content_manual: http://www.witas.be/nl/duco
