Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T01:28:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 01:28:44 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{AE88C0CF-AB14-4A7B-BDD6-78DD23E0A6D3}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 01:28:39 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 01:28:39 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 01:28:39 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcBuildingElementProxy: connector communication_gen (3)
In: Level 1
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Identity Data(Type) - Type Name: connector communication_gen
Type - Other(Type) - Category: Communication Devices; Family Name: RSen_XX_GM_FB_connector communication_gen
Pset_BuildingElementProxyCommon - Reference: connector communication_gen
Dimensions - Area: 0.0000942373 m2; Volume: 7.85051e-08 m3
Other - Category: Communication Devices; Family: RSen_XX_GM_FB_connector communication_gen: connector communication_gen; Family and Type: RSen_XX_GM_FB_connector communication_gen: connector communication_gen; Type: RSen_XX_GM_FB_connector communication_gen: connector communication_gen; Type Id: RSen_XX_GM_FB_connector communication_gen: connector communication_gen; WT_c1 utility: no
Phasing - Phase Created: New Construction
Name (RSen_XX_GM_FB_connector communication_gen:connector communication_gen:...) | Mark | WT_c1 Description
200941 | 2 | c2_2 or 3 point control
200942 | 3 | c3_PWM out
200943 | 4 | c4_duco Wired

# IfcDistributionControlElement: actuator print_duco_with housing, RSen_67_COM_FB_actuator control_duco:actuator print_duco_with housing:200939
In: Level 1
Type - Classification: 67.10 (Uniformat)
Type - Constraints(Type) - Default Elevation: 1200 mm
Type - Dimensions(Type) - RSen_C_depth: 58 mm; RSen_C_height: 80 mm; RSen_C_width: 146 mm
Type - Electrical(Type) - RSen_E_c01_active_power: 0 W; RSen_E_c01_division_engine: yes; RSen_E_c01_load_class: HVAC; RSen_E_c01_number_of_poles: 1; RSen_E_c01_power_factor: 1; RSen_E_c01_voltage: 220 V
Type - Graphics(Type) - WT_V Visible: yes
Type - Identity Data(Type) - Assembly Code: 67.10; Description: actuator control_duco_with housing; Manufacturer: Duco; Model: actuator control; RSen_C_code_ETIM: Electrical drive train with round duct control valve; RSen_C_code_ETIM_URL: http://prod.etim-international.com/Class/Details?classId=EC003086&classVersion=1; RSen_C_code_gtin: 5425037150071; RSen_C_code_product: 0000-4195; RSen_C_content_creator: ThorbiQ nv; RSen_C_content_date_changed: 23/03/2018; RSen_C_content_date_issue: 26/02/2016; RSen_C_content_provider: Duco; RSen_C_content_version: V4; RSen_C_description: actuator control_duco_with housing; RSen_C_model: actuator control; RSen_C_revit_version: 2016; RSen_C_type: with housing; RSen_C_type_comments: Actuator control; Type Comments: Actuator control; Type Name: actuator print_duco_with housing; URL: http://www.duco.eu; WT_I BaseKeynote: 67.10.10
Type - Model Properties(Type) - WT_I Color housing: White; WT_I Communication: Wired; WT_I Connections: 2- of 3-puntssturing (3 aders); PWM out (2 aders); Duco Wired (5 aders); WT_I Type: Actuator control
Type - Other(Type) - Category: Communication Devices; Family Name: RSen_67_COM_FB_actuator control_duco; RSen_E_c01_description: c1_elektrical connector; RSen_E_c02_description: c2_2 or 3 point control; RSen_E_c03_description: c3_PWM out; RSen_E_c04_description: c4_duco Wired
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Construction - WT_V 2- or 3 point control: yes; WT_V Duco Wired: yes; WT_V PWM out: yes
Dimensions - Area: 0.024788 m2; Volume: 0.00067744 m3
Electrical - Circuiting - Electrical Data: c1_elektrical connector 220 V/1-0 VA
Graphics - WT_V Move annotation x: 0 mm; WT_V Move annotation y: 0 mm; WT_V Position annotation x: 0; WT_V Position annotation y: 0
Identity Data - Mark: 1
Other - Category: Communication Devices; Family: RSen_67_COM_FB_actuator control_duco: actuator print_duco_with housing; Family and Type: RSen_67_COM_FB_actuator control_duco: actuator print_duco_with housing; Schedule Level: Level: Level 1; Type: RSen_67_COM_FB_actuator control_duco: actuator print_duco_with housing; Type Id: RSen_67_COM_FB_actuator control_duco: actuator print_duco_with housing
Phasing - Phase Created: New Construction
Text - RSen_C_content_manual: http://www.witas.be/nl/duco
