Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T01:28:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 01:28:53 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{E9FC0CA5-4FF6-4551-B499-B0C8DB6BCC39}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 01:28:50 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 01:28:50 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 01:28:50 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point

# IfcBuildingElementProxy: connector electrical_gen, RSen_XX_GM_FB_connector electrical_gen:connector electrical_gen:202904
In: Level 1
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Identity Data(Type) - RSen_C_description: connector electrical_gen; Type Name: connector electrical_gen
Type - Other(Type) - Category: Communication Devices; Family Name: RSen_XX_GM_FB_connector electrical_gen
Pset_BuildingElementProxyCommon - Reference: connector electrical_gen
Dimensions - Area: 0.0000942373 m2; Volume: 7.85051e-08 m3
Electrical - RSen_E_c02_load_class: HVAC; RSen_E_c02_number_of_poles: 1; RSen_E_c02_power_factor: 1; BERSnl_E_c02_subklasse_motor: no; RSen_E_c02_voltage: 24 V; RSen_E_power: 1.6 W
Electrical - Circuiting - Electrical Data: c2_elektrical connector 24 V/1-2 VA
Identity Data - Mark: 2
Other - Category: Communication Devices; Family: RSen_XX_GM_FB_connector electrical_gen: connector electrical_gen; Family and Type: RSen_XX_GM_FB_connector electrical_gen: connector electrical_gen; Type: RSen_XX_GM_FB_connector electrical_gen: connector electrical_gen; Type Id: RSen_XX_GM_FB_connector electrical_gen: connector electrical_gen; WT_c1 Description: c2_elektrical connector; WT_c2 utility: no
Phasing - Phase Created: New Construction

# IfcDistributionControlElement: co2 space sensor - wired_duco, RSen_67_COM_FB_co2 space sensor_duco:co2 space sensor - wired_duco:202902
In: Level 1
Type - Classification: 67.10.10 (Uniformat); Material: RSen_n_plastic_white, RSen_n_plastic_black
Type - Constraints(Type) - Default Elevation: 1200 mm; ZZZ_electrical connector_YesNo: yes
Type - Construction(Type) - WT_V Fitting depth: 40 mm; WT_V Thickness cover frame: 20 mm
Type - Dimensions(Type) - RSen_C_height: 83 mm; RSen_C_thickness: 60 mm; RSen_C_width: 83 mm
Type - Electrical(Type) - RSen_E_c02_active_power: 1.6 W; RSen_E_c02_load_class: HVAC; RSen_E_c02_number_of_poles: 1; RSen_E_c02_power_factor: 1; RSen_E_c02_voltage: 24 V; WT_I Stand-By power: 0.7 W
Type - Identity Data(Type) - Assembly Code: 67.10.10; Description: co2 space sensor - wired_duco_co2 space sensor; Manufacturer: Duco; Model: co2 space sensor; RSen_C_code_ETIM: Space air quality recorder; RSen_C_code_ETIM_URL: http://prod.etim-international.com/Class/Details?classId=EC010952&classVersion=5; RSen_C_code_gtin: 5 4 2503715 061 3; RSen_C_code_product: 0000-4204; RSen_C_content_creator: ThorbiQ nv; RSen_C_content_date_changed: 23/03/2018; RSen_C_content_date_issue: 26/02/2016; RSen_C_content_provider: Duco; RSen_C_content_version: V4; RSen_C_description: co2 space sensor - wired_duco_co2 space sensor; RSen_C_model: co2 space sensor; RSen_C_revit_version: 2016; RSen_C_type: wired; RSen_C_type_comments: co2 space sensor; Type Comments: co2 space sensor; Type Name: co2 space sensor - wired_duco; URL: http://www.duco.eu/nl-nl-producten/nl-nl-ventilatiesystemen/nl-nl-sturingscomponenten/nl-nl-bedieningsschakelaar; WT_I BaseKeynote: 67.10.10
Type - Materials and Finishes(Type) - RSen_C_material: RSen_n_plastic_white
Type - Model Properties(Type) - WT_I CO2 accuracy: 50 ppm +/- 5%; WT_I CO2 range: 400 – 2000 ppm; WT_I Color housing: black control; WT_I Color indication LED_BLUE: Visualisation of the control switch when changes are made through the DucoBox; WT_I Color indication LED_GREEN_fast blinking: In network and awaiting underlying components (f.e. electronical grids); WT_I Color indication LED_GREEN_slow blinking: In network; WT_I Color indication LED_RED_fast blinking: Signing in; WT_I Color indication LED_RED_slow blinking: Not in network; WT_I Color indication LED_YELLOW_blinking: Transition phase(if DucoBox not in range); WT_I Fitting box_depth: 40 mm; WT_I Polarity protection: Graetz bridge; WT_I Protocol: Z-wave; WT_I Type: Wired_24VDC
Type - Other(Type) - Category: Communication Devices; Family Name: RSen_67_COM_FB_co2 space sensor_duco; RSen_E_c01_description: c1_communication connector; RSen_E_c02_description: c2_elektrical connector
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.0170067 m2; Volume: 0.000419885 m3
Graphics - WT_V Move annotation x: 0 mm; WT_V Move annotation y: 0 mm; WT_V Position annotation x: 0; WT_V Position annotation y: 0
Identity Data - Mark: 1
Other - Category: Communication Devices; Family: RSen_67_COM_FB_co2 space sensor_duco: co2 space sensor - wired_duco; Family and Type: RSen_67_COM_FB_co2 space sensor_duco: co2 space sensor - wired_duco; Schedule Level: Level: Level 1; Type: RSen_67_COM_FB_co2 space sensor_duco: co2 space sensor - wired_duco; Type Id: RSen_67_COM_FB_co2 space sensor_duco: co2 space sensor - wired_duco
Phasing - Phase Created: New Construction
Text - RSen_C_content_manual: http://www.witas.be/nl/duco
