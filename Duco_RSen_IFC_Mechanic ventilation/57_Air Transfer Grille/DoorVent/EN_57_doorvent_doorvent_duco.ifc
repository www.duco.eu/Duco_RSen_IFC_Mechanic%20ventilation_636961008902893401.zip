Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T01:25:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 01:25:42 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{F5D7A645-0B0D-47EF-971E-BB2E0706D2C9}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 01:25:40 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 01:25:40 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 01:25:40 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFlowTerminal: doorvent_duco_doorvent, RSen_57_AIR_FB_air transfer grill - doorvent_duco:doorvent_duco_doorvent:205107
In: Level 1
Type - PredefinedType: GRILLE; Classification: 57.10.90.1 (Uniformat); Material: RSen_h4_aluminium, RSen_n_plastic_black
Type - Constraints(Type) - Default Elevation: 200 mm; ZZZ_cutout bottom_height_Length: 5 mm; ZZZ_cutouts_height_Length: 48 mm; ZZZ_cutout top_height_Length: 5 mm; ZZZ_end caps_length_Length: 9.5 mm; ZZZ_installation on door_YesNo: yes; ZZZ_Terminal exterior_depth_Length: 2 mm; ZZZ_Terminal interior_depth_Length: 2 mm
Type - Dimensions(Type) - RSen_C_height: 58 mm; RSen_C_length: 436 mm; WT_V Height grille: 45 mm
Type - Identity Data(Type) - Assembly Code: 57.10.90.1; Manufacturer: Duco; Model: DoorVent; OmniClass Number: 3A(57.16.11); RSen_C_code_article: DoorVent; RSen_C_code_ETIM: Transfer air grille; RSen_C_code_ETIM_URL: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; RSen_C_content_creator: ThorbiQ nv; RSen_C_content_date_changed: 23/03/2018; RSen_C_content_date_issue: 26/02/2016; RSen_C_content_provider: Duco; RSen_C_content_version: V4; RSen_C_description: duco_air transfer grille_doorvent; RSen_C_model: DoorVent; RSen_C_revit_version: 2016; Type Name: doorvent_duco_doorvent; URL: http://www.duco.eu/producten/specificaties.cfm?prod=126&pid=3-126&cat=126; WT_I BaseKeynote: 57.10.90.1
Type - Materials and Finishes(Type) - RSen_C_material: RSen_h4_aluminium; WT_V End caps_material: RSen_n_plastic_black; WT_V Grille_material: RSen_a_perforated; WT_V Inner Profile_material: RSen_h4_aluminium; WT_V outer profile_material: RSen_h4_aluminium
Type - Mechanical - Flow(Type) - WT_I Ventilation capacity 10Pa: 0.52972 m3/s; WT_I Ventilation capacity 2Pa: 0.245241 m3/s
Type - Model Properties(Type) - WT_I Air flow: 0.007 m2; WT_I Color: SAA - RAL; WT_I Door_MAX depth: 47 mm; WT_I Door_MIN depth: 37 mm; WT_I Sound level difference Dne, W_in open position: 32 dB
Type - Other(Type) - Category: Air Terminals; Family Name: RSen_57_AIR_FB_air transfer grill - doorvent_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: doorvent_duco_doorvent
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; ZZZ_cutouts_length_Length: 417 mm; ZZZ_doors_depth_Length: 37 mm; ZZZ_length arrow_Length: 241 mm; ZZZ_Terminal interior_length_Length: 413 mm
Construction - WT_V Door_depth: 37 mm
Dimensions - Area: 0.159529 m2; RSen_C_depth: 41 mm; Volume: 0.000968693 m3
Identity Data - Mark: 1
Mechanical - Flow - BE_M_pressure_difference_10Pa: no; BE_M_pressure_difference_2Pa: yes; RSen_M_flow_rate: 0.101284 m3/s
Other - Category: Air Terminals; Family: RSen_57_AIR_FB_air transfer grill - doorvent_duco: doorvent_duco_doorvent; Family and Type: RSen_57_AIR_FB_air transfer grill - doorvent_duco: doorvent_duco_doorvent; Schedule Level: Level: Level 1; Type: RSen_57_AIR_FB_air transfer grill - doorvent_duco: doorvent_duco_doorvent; Type Id: RSen_57_AIR_FB_air transfer grill - doorvent_duco: doorvent_duco_doorvent
Phasing - Phase Created: New Construction
Text - RSen_C_content_manual: http://www.witas.be/nl/duco
