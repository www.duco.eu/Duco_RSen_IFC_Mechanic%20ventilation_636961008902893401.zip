Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T01:28:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 01:28:24 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{8EFCFABD-3024-42AD-BB81-7F7A8B6565DF}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 01:28:19 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 01:28:19 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 01:28:19 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: control valve vocht_duco_intelli air valve, RSen_59_DUA_UN_control valve - intelli air valve_duco:control valve vocht_duco_intelli air valve:201832
In: Level 1
Type - PredefinedType: CONTROLDAMPER; Classification: 57.10.90.80 (Uniformat)
Type - Constraints(Type) - ZZZ_Behuizing_FamilyType_Duct Accessories: standard; ZZZ_Connection_length_Length: 30 mm; ZZZ_Connection_radius_HVACDuctSize: 0 mm
Type - Dimensions(Type) - RSen_C_height: 192 mm; RSen_C_length: 138 mm; RSen_C_width: 125 mm
Type - Electrical(Type) - RSen_E_c03_active_power: 0 W; RSen_E_c03_apparent_power: 0 W; RSen_E_c03_current: 0 A; RSen_E_c03_load_class: HVAC; RSen_E_c03_number_of_poles: 1; RSen_E_c03_power_factor: 0; RSen_E_c03_voltage: 0 V; WT_I Stand-By power: 0 W
Type - Identity Data(Type) - Assembly Code: 57.10.90.80; Description: duco_intelli air valve - control valve humidity; Manufacturer: Duco; Model: intelli air valve; OmniClass Number: 23.75.70.14.34; OmniClass Title: Air Duct Accessories; RSen_C_code_ETIM: Control valve round duct; RSen_C_code_ETIM_URL: http://prod.etim-international.com/Class/Details?classId=EC011268&classVersion=3; RSen_C_code_product: 0000-4242; RSen_C_content_creator: ThorbiQ nv; RSen_C_content_date_changed: 23/03/2018; RSen_C_content_date_issue: 26/02/2016; RSen_C_content_provider: Duco; RSen_C_content_version: V2; RSen_C_description: duco_intelli air valve - control valve humidity; RSen_C_IFC_version: 2x3; RSen_C_model: intelli air valve; RSen_C_revit_version: 2016; RSen_C_type: control valve humidity; RSen_C_type_comments: Control valve; Type Comments: Control valve; Type Name: control valve vocht_duco_intelli air valve; URL: http://www.duco.eu; WT_I BaseKeynote: 57.10.90.80
Type - Mechanical - Flow(Type) - RSen_M_c01_flow_rate: 0 m3/s; RSen_M_c02_flow_rate: 0 m3/s
Type - Mechanical(Type) - RSen_M_c01_diameter: 0 mm
Type - Model Properties(Type) - RSen_S_weight_gross: 0
Type - Other(Type) - Category: Duct Accessories; Family Name: RSen_59_DUA_UN_control valve - intelli air valve_duco; RSen_E_c03_description: c03_connector; RSen_M_c01_description: c01_connector; RSen_M_c02_description: c02_connector
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: control valve vocht_duco_intelli air valve
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm; ZZZ_body_length_Length: 78 mm
Dimensions - Area: 0.190477 m2; Size: 0 mmø-0 mmø; Volume: 0.00757286 m3
Identity Data - Mark: 2
Insulation - Insulation Thickness: 0 mm; Overall Size: 0 mmø-0 mmø
Lining - Free Size: 0 mmø-0 mmø; Lining Thickness: 0 mm
Mechanical - System Classification: Undefined,Power
Other - Category: Duct Accessories; Family: RSen_59_DUA_UN_control valve - intelli air valve_duco: control valve vocht_duco_intelli air valve; Family and Type: RSen_59_DUA_UN_control valve - intelli air valve_duco: control valve vocht_duco_intelli air valve; Type: RSen_59_DUA_UN_control valve - intelli air valve_duco: control valve vocht_duco_intelli air valve; Type Id: RSen_59_DUA_UN_control valve - intelli air valve_duco: control valve vocht_duco_intelli air valve
Phasing - Phase Created: New Construction
Text - RSen_C_content_manual: http://www.witas.be/nl/duco
