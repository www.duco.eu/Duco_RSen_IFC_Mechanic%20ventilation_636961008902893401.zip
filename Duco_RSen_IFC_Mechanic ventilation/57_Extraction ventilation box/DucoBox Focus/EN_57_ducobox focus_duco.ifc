Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T01:27:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 01:27:08 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{A75152A4-A7F5-437C-8589-AFC255636D7F}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 01:26:54 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 01:26:54 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 01:26:54 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcEnergyConversionDevice: ducobox focus_duco, RSen_57_ME_FB_extraction ventilator - ducobox focus_duco:ducobox focus_duco:203196
In: Level 1
Type - PredefinedType: AIRHANDLER; Classification: 57.21 (Uniformat); Material: RSen_x_rgb 000 149 150 T00 green_gen, RSen_x_rgb 255 255 255 T00 white_gen
Type - Constraints(Type) - Default Elevation: 1219.2 mm; ZZZ_Connection_thickness_Length: 36 mm; ZZZ_exhaust_diameter_HVACDuctSize: 125 mm; ZZZ_exhaust_radius_Length: 62.5 mm; ZZZ_extraction_diameter_Length: 125 mm; ZZZ_extraction_radius_Length: 62.5 mm
Type - Construction(Type) - WT_V Maintenance area_depth: 400 mm
Type - Dimensions(Type) - RSen_C_depth: 195 mm; RSen_C_height: 480 mm; RSen_C_width: 480 mm
Type - Electrical(Type) - RSen_E_c01_apparent_power: 230 W; RSen_E_c01_current: 1 A; RSen_E_c01_division_engine: no; RSen_E_c01_load_class: HVAC; RSen_E_c01_number_of_poles: 1; RSen_E_c01_power_factor: 1; RSen_E_c01_voltage: 230 V
Type - Identity Data(Type) - Assembly Code: 57.21; Description: DucoBox Focus_Duco; Manufacturer: Duco; Model: DucoBox Focus; OmniClass Number: 3A(57.31.11); RSen_C_code_ETIM: Home ventilation unit; RSen_C_code_ETIM_URL: http://prod.etim-international.com/Class/Details?classId=EC010004&classVersion=5; RSen_C_code_gtin: 5425037151597; RSen_C_code_product: 0000-4252; RSen_C_content_creator: ThorbiQ nv; RSen_C_content_date_changed: 23/03/2018; RSen_C_content_date_issue: 26/02/2016; RSen_C_content_provider: Duco; RSen_C_content_version: V4; RSen_C_description: DucoBox Focus_Duco; RSen_C_model: DucoBox Focus; RSen_C_revit_version: 2016; RSen_C_type_comments: Extraction ventilator; Type Comments: Extraction ventilator; Type Name: ducobox focus_duco; URL: http://www.duco-professionals.eu/Wes/CDN/1/Attachments/Technische%20Fiche%20DucoBox%20Focus%20NL_635387046832407791.pdf; WT_I BaseKeynote: 57.10.10
Type - Mechanical(Type) - WT_V Capacity: 3.92385 m3/s; WT_V Elevating height: 150 Pa
Type - Model Properties(Type) - WT_I Extraction_control: Central; WT_I Patented control valve system: yes; WT_I Sound power_air intake: 58; WT_I Sound power_dispersion box: 49
Type - Other(Type) - Category: Mechanical Equipment; Family Name: RSen_57_ME_FB_extraction ventilator - ducobox focus_duco; RSen_E_c01_description: c1_electrical connection; RSen_E_c02_description: c2_communication connector; RSen_M_c01_description: c1_exhaust; RSen_M_c01_radius: 62.5 mm; RSen_M_c02_description: c2_extraction 1; RSen_M_c03_description: c3_extraction 2; RSen_M_c04_description: c4_extraction 3; RSen_M_c05_description: c5_extraction 4; RSen_M_c06_description: c6_Extraction 5; RSen_M_c06_radius: 62.5 mm; RSen_M_c07_description: c7_extraction 6; RSen_M_c07_radius: 62.5 mm; RSen_M_c08_description: c8_extraction 7; RSen_M_c08_radius: 62.5 mm
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: ducobox focus_duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Construction - WT_V Connection_Wireless: no; WT_V Control_Plug IQ: yes; WT_V Control_Plug PWM print + external IQ: no; WT_V End cap visible_1: yes; WT_V End cap visible_2: yes; WT_V End cap visible_3: yes; WT_V End cap visible_4: yes; WT_V End cap visible_5: yes; WT_V End cap visible_6: yes; WT_V End cap visible_7: yes; WT_V Extraction 1_air valve: none_gen; WT_V Extraction 2_air valve: none_gen; WT_V Extraction 3_air valve: none_gen; WT_V Extraction 4_air valve: none_gen; WT_V Extraction 5_air valve: none_gen; WT_V Extraction 6_air valve: none_gen; WT_V Extraction 7_air valve: none_gen
Dimensions - Area: 1.1873 m2; Volume: 0.044928 m3
Graphics - WT_V Maintenance area visible: no
Identity Data - Mark: 1
Mechanical - System Classification: Return Air,Exhaust Air,Return Air,Power,Communication,Return Air
Mechanical - Flow - RSen_M_flow_rate: 0 m3/s
Other - Category: Mechanical Equipment; Family: RSen_57_ME_FB_extraction ventilator - ducobox focus_duco: ducobox focus_duco; Family and Type: RSen_57_ME_FB_extraction ventilator - ducobox focus_duco: ducobox focus_duco; RSen_M_c01_flow_rate: 0 m3/s; RSen_M_c02_flow_rate: 0 m3/s; RSen_M_c02_radius: 62.5 mm; RSen_M_c03_flow_rate: 0 m3/s; RSen_M_c03_radius: 62.5 mm; RSen_M_c04_flow_rate: 0 m3/s; RSen_M_c04_radius: 62.5 mm; RSen_M_c05_flow_rate: 0 m3/s; RSen_M_c05_radius: 62.5 mm; RSen_M_c06_flow_rate: 0 m3/s; RSen_M_c07_flow_rate: 0 m3/s; RSen_M_c08_flow_rate: 0 m3/s; Schedule Level: Level: Level 1; Type: RSen_57_ME_FB_extraction ventilator - ducobox focus_duco: ducobox focus_duco; Type Id: RSen_57_ME_FB_extraction ventilator - ducobox focus_duco: ducobox focus_duco
Phasing - Phase Created: New Construction
Text - RSen_C_content_manual: http://www.witas.be/nl/duco
