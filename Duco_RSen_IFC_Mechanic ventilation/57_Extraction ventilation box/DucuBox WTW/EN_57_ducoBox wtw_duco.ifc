Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T01:28:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 01:28:08 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{3D08D949-6A35-4023-8E4E-7D441BBA5ADA}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 01:28:01 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 01:28:01 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 01:28:01 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point

# IfcEnergyConversionDevice: ducoBox wtw_duco, RSen_57_ME_FB_extraction ventilator - ducubox wtw_duco:ducoBox wtw_duco:204789
In: Level 1
Type - PredefinedType: AIRHANDLER; Classification: 57.21 (Uniformat); Material: RSen_x_rgb 255 255 255 T00 white_gen, RSen_o_glass_clear, RSen_n_plastic_black, RSen_x_rgb 000 149 150 T00 green_gen
Type - Constraints(Type) - Default Elevation: 1219.2 mm; ZZZ_Connection_thickness_Length: 50 mm; ZZZ_exhaust_radius_Length: 75 mm; ZZZ_extraction_radius_Length: 75 mm
Type - Construction(Type) - WT_V Maintenance area_depth: 400 mm; WT_V Wall distance: 29.9626 mm
Type - Dimensions(Type) - RSen_C_depth: 466 mm; RSen_C_height: 777 mm; RSen_C_width: 610 mm
Type - Electrical(Type) - RSen_E_c01_apparent_power: 230 W; RSen_E_c01_current: 1 A; RSen_E_c01_division_engine: no; RSen_E_c01_load_class: HVAC; RSen_E_c01_number_of_poles: 1; RSen_E_c01_power_factor: 1; RSen_E_c01_voltage: 230 V; WT_I Average electrical power consumption: 300 W; WT_I Max electrical power consumption: 500 W
Type - Identity Data(Type) - Assembly Code: 57.21; Description: ducoBox wtw_duco; Manufacturer: Duco; Model: DucoBox WTW; OmniClass Number: 3A(57.31.11); RSen_C_code_ETIM: Home ventilation unit; RSen_C_code_ETIM_URL: http://prod.etim-international.com/Class/Details?classId=EC010004&classVersion=5; RSen_C_code_gtin: 5 4 2503715 025 5; RSen_C_code_product: 0000-4196; RSen_C_content_creator: ThorbiQ nv; RSen_C_content_date_changed: 23/03/2018; RSen_C_content_date_issue: 26/02/2016; RSen_C_content_provider: Duco; RSen_C_content_version: V4; RSen_C_description: ducoBox wtw_duco; RSen_C_model: DucoBox WTW; RSen_C_revit_version: 2016; RSen_C_type_comments: Extraction ventilator; Type Comments: Extraction ventilator; Type Name: ducoBox wtw_duco; URL: http://www.duco-professionals.eu/Wes/CDN/1/Attachments/Technische%20Fiche%20DucoBox%20Focus%20NL_635387046832407791.pdf; WT_I BaseKeynote: 57.10.10
Type - Mechanical(Type) - WT_V Capacity: 2.94289 m3/s; WT_V Elevating height: 100 Pa; WT_V Exhaust_diameter: 150 mm; WT_V Extraction_diameter: 150 mm
Type - Model Properties(Type) - WT_I C O P_20˚C_45˚C: 4,2; WT_I Extraction_control: Central; WT_I Share of heat supply central heating: 25 - 95 %; WT_I Sound level bandwidth: 34 - 41 dB; WT_I System release: LT >35 - HT 80/60 ˚C; WT_I Thermal central heating capacity: 1,2-1,4 KWth
Type - Other(Type) - Category: Mechanical Equipment; Family Name: RSen_57_ME_FB_extraction ventilator - ducubox wtw_duco; RSen_E_c01_description: c1_electrical connection; RSen_M_c01_description: c1_exhaust; RSen_M_c01_radius: 75 mm; RSen_M_c02_description: c2_extraction 1; RSen_P_c01_description: c1_Heating supply; RSen_P_c01_radius: 11 mm; RSen_P_c01_volume_flow: 0 m3/s; RSen_P_c02_description: c2_heating return; RSen_P_c02_radius: 11 mm; RSen_P_c02_volume_flow: 0 m3/s; RSen_P_c03_description: c3_condensate drain; RSen_P_c03_radius: 11 mm
Type - Plumbing(Type) - RSen_P_c03_load_value: 0; WT_V Connection diameter condensate drain: 22 mm; WT_V Connection diameter CVr: 22 mm; WT_V Connection diameter CVv: 22 mm
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: ducoBox wtw_duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Construction - WT_V Connection_Wireless: no; WT_V Control_Plug IQ: yes; WT_V Control_Plug PWM print + external IQ: no
Dimensions - Area: 10.1721 m2; Volume: 1.3606 m3
Graphics - WT_V Maintenance area visible: no
Identity Data - Mark: 1
Mechanical - System Classification: Return Air,Power,Communication,Exhaust Air,Hydronic Supply,Hydronic Return,Sanitary; WT_I Capacity: OK
Mechanical - Flow - RSen_M_flow_rate: 0 m3/s
Other - Category: Mechanical Equipment; Family: RSen_57_ME_FB_extraction ventilator - ducubox wtw_duco: ducoBox wtw_duco; Family and Type: RSen_57_ME_FB_extraction ventilator - ducubox wtw_duco: ducoBox wtw_duco; RSen_M_c01_flow_rate: 0 m3/s; RSen_M_c02_flow_rate: 0 m3/s; RSen_M_c02_radius: 75 mm; Schedule Level: Level: Level 1; Type: RSen_57_ME_FB_extraction ventilator - ducubox wtw_duco: ducoBox wtw_duco; Type Id: RSen_57_ME_FB_extraction ventilator - ducubox wtw_duco: ducoBox wtw_duco
Phasing - Phase Created: New Construction
Plumbing - RSen_P_volume_flow: 0 m3/s
Text - RSen_C_content_manual: http://www.witas.be/nl/duco

# IfcFlowController: none_gen (3)
In: Level 1
Type - Constraints(Type) - Default Elevation: 0 mm
Type - Identity Data(Type) - RSen_C_code_ETIM: Home ventilation unit; RSen_C_content_date_changed: 26/02/2028; RSen_C_content_date_issue: 26/02/2028; Type Name: none_gen
Type - Mechanical(Type) - Loss Method: Not Defined
Type - Other(Type) - Category: Pipe Accessories; Family Name: RSen_59_PIA_FB_accessoiry connection_gen_witas
Pset_DistributionFlowElementCommon - Reference: none_gen
Constraints - Moves With Nearby Elements: no
Dimensions - Volume: 0.0000064399 m3
Graphics - WT_V References visible: yes
Insulation - Insulation Thickness: 0 mm
Other - Category: Pipe Accessories; Family: RSen_59_PIA_FB_accessoiry connection_gen_witas: none_gen; Family and Type: RSen_59_PIA_FB_accessoiry connection_gen_witas: none_gen; Type: RSen_59_PIA_FB_accessoiry connection_gen_witas: none_gen; Type Id: RSen_59_PIA_FB_accessoiry connection_gen_witas: none_gen
Phasing - Phase Created: New Construction
Name (RSen_59_PIA_FB_accessoiry connection_gen_witas:none_gen:...) | Mark
204791 | 1
204792 | 2
204793 | 3
